# Keil uVision project sample.uvprojx, settings and files
target LandTiget_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pacman
  c flags: Optim=2 v6Lang=3 v6LangP=3
  c include: .\Source;.\Source\button_EXINT;.\Source\timer;.\Source\CMSIS_core;.\Source\RIT;.\Source\joystick;.\Source\GLCD;.\Source\ADC;.\Source\speaker;.\Source\characters;.\Source\assets;.\Source\CAN
  asm include: .\Source;.\Source\button_EXINT;.\Source\led;.\Source\timer;.\Source\CMSIS_core
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./Source/: startup_LPC17xx.s
  group main
    ./Source/: sample.c
  group lib_SoC_board
    ./Source/: system_LPC17xx.c
  group button_EINT
    ./Source/button_EXINT/: button.h IRQ_button.c lib_button.c
  group timer
    ./Source/timer/: IRQ_timer.c lib_timer.c timer.h
  group CMSIS_core
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group RIT
    ./Source/RIT/: lib_RIT.c IRQ_RIT.c RIT.h
  group joystick
    ./Source/joystick/: funct_joystick.c joystick.h lib_joystick.c
  group ADC
    ./Source/adc/: adc.h IRQ_adc.c lib_adc.c
  group speaker
    ./Source/speaker/: assets_speaker.c funct_speaker.c speaker.h
  group GLCD
    ./Source/GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h funct_GLCD.c HzLib.c HzLib.h
  group characters
    ./Source/characters/: player.c player.h
  group assets
    ./Source/assets/: big_dot.c blinky.c blue_ghost.c down_1.c down_2.c down_3.c image.h left_1.c left_2.c left_3.c maze.c ready.c right_1.c right_2.c right_3.c small_dot.c up_1.c up_2.c up_3.c white_ghost.c
  group CAN
    ./Source/CAN/: CAN.h IRQ_CAN.c lib_CAN.c
target SW_Debug (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: sample_TIMER
  c flags: Optim=2 v6Lang=3 v6LangP=3
  c define: SIMULATTOR
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0
